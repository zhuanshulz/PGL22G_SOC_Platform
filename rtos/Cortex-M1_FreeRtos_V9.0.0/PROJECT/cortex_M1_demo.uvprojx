# Keil uVision project cortex_M1_demo.uvprojx, settings and files
target cortex_M1_demo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM1 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M1") CLOCK(12000000) ESEL ELITTLE
  output: cortex_M1_demo +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin  -o  cortex_M1_demo.bin .\Objects\cortex_M1_demo.axf
  AfterMake: make_hex128.exe cortex_M1_demo.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\CORE;..\PERIPHERAL\inc;..\STARTUP;..\SYSTEM;..\USER;..\FreeRTOS;..\FreeRTOS\include;..\FreeRTOS\portable\Keil\ARM_CM1;..\FatFs
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x10000
  memory RVCT9: RAM 0x30000000 size 0x10000
  group STARTUP
    ../STARTUP/: startup_PANGO_M1.s
  group SYSTEM
    ../SYSTEM/: system_PANGO_M1.c
  group PERIPHERAL
    ../PERIPHERAL/src/: PANGO_M1_gpio.c PANGO_M1_spi.c PANGO_M1_timer.c PANGO_M1_uart.c PANGO_M1_wdog.c PANGO_M1_printk.c PANGO_M1_i2c.c PANGO_M1_memory.c
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/Keil/ARM_CM1/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group USER
    ../USER/: main.c PANGO_M1_it.c PANGO_spi_flash.c PANGO_i2c_eeprom.c
  group SDcard
    ../USER/: PANGO_sdcard.c
  group FatFS
    ../FatFs/: diskio.c ff.c ffsystem.c ffunicode.c
